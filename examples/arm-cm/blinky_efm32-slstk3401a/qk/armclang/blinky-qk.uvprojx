# Keil uVision project blinky-qk.uvprojx, settings and files
target blinky-dbg (6160000::V6.16::ARMCLANG)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32PG1B_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky-qk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky-qk.bin .\dbg\blinky-qk.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\efm32pg1b
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.c
    ../../: blinky.c main.c blinky.h
    ../../../../../src/qs/: qstamp.c
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/arm/: startup_efm32pg1b.s
    ../../../../../3rd_party/efm32pg1b/: em_cmu.c em_emu.c em_gpio.c em_int.c em_rtcc.c em_system.c system_efm32pg1b.c
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qk/: qk.c
  group QP_port
    ../../../../../ports/arm-cm/qk/armclang/: qk_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c
target blinky-rel (6130001::V6.13.1::.\ARMCLANG)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32PG1B_DFP.4.0.0
  cpu: as above
  output: blinky-qk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky-qk.bin .\rel\blinky-qk.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
target blinky-spy (6130001::V6.13.1::.\ARMCLANG)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32PG1B_DFP.4.0.0
  cpu: as above
  output: blinky-qk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\blinky-qk.bin .\spy\blinky-qk.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
