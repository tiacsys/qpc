# Keil uVision project dpp-qxk.uvprojx, settings and files
target dpp-dbg (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qxk
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qxk.bin .\dbg\dpp-qxk.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: QF_ON_CONTEXT_SW
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qxk\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-c031c6
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\dpp-qxk.sct
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c main.c test.c
    ../../: bsp.h dpp.h philo.c table.c
    ./: dpp-qxk.sct
  group nucleo-c031c6
    ../../../../../3rd_party/nucleo-c031c6/: stm32c0xx.h stm32c031xx.h system_stm32c0xx.c
    ../../../../../3rd_party/nucleo-c031c6/arm/: startup_stm32c031xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/armclang/: qep_port.h qf_port.h qs_port.h qxk_port.c qxk_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c
target dpp-rel (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qxk.bin .\rel\dpp-qxk.axf
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: NDEBUG,QF_ON_CONTEXT_SW
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\dpp-qxk.sct
  link misc: --entry Reset_Handler
target dpp-spy (6160000::V6.16::ARMCLANG)
  device: STM32C031C6Tx STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: as above
  output: dpp-qxk
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qxk.bin .\spy\dpp-qxk.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY,QF_ON_CONTEXT_SW
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\dpp-qxk.sct
  link misc: --entry Reset_Handler
