# IAR project dpp-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: QF_ON_CONTEXT_SW
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qxk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\ek-tm4c123gxl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-qxk.out
  ILINK.IlinkIcfFile: dpp-qxk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; QF_ON_CONTEXT_SW
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: Q_SPY; QF_ON_CONTEXT_SW
  ICCARM.CCOptLevel: 1
  group Application
    ../: bsp.c main.c test.c
    ../../: bsp.h dpp.h philo.c table.c
    ../../../../../src/qs/: qstamp.c
  group ek-tm4c123gxl
    ../../../../../3rd_party/ek-tm4c123gxl/iar/: startup_TM4C123GH6PM.s
    ../../../../../3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h qxk_pkg.h
    ../../../../../src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../../ports/arm-cm/qxk/iar/: qxk_port.c qxk_port.h
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../../src/: qs_pkg.h
