# Keil uVision project dpp-qv.uvprojx, settings and files
target dpp-dbg (6130001::V6.13.1::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dpp-qv
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\dpp-qv.bin .\dbg\dpp-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qv\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\mbed-lpc1768
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c
    ../../../../../src/qs/: qstamp.c
  group mbed-lpc1768
    ../../../../../3rd_party/mbed-lpc1768/: system_LPC17xx.c
    ../../../../../3rd_party/mbed-lpc1768/arm/: startup_LPC17xx.s
  group QP
    ../../../../../src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../../src/: qf_pkg.h
    ../../../../../src/qv/: qv.c
  group QP_port
    ../../../../../ports/arm-cm/qv/armclang/: qep_port.h qf_port.h qv_port.h qs_port.h qv_port.c
  group QS
    ../../../../../src/qs/: qs.c qs_fp.c qs_pkg.h
    ../../../../../src/: qs_pkg.h
target dpp-rel (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: dpp-qv
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\dpp-qv.bin .\rel\dpp-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --entry Reset_Handler
target dpp-spy (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: dpp-qv
  BeforeMake: cmd /c "del .\spy\qstamp.o"
  AfterMake: fromelf --bin --output .\spy\dpp-qv.bin .\spy\dpp-qv.axf
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: Q_SPY __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=2048 Heap_Size=16
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --entry Reset_Handler
