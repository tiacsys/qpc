# Keil uVision project test_efm32.uvprojx, settings and files
target test_efm32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32PG1B_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_efm32
  BeforeMake: cmd /c "del .\dbg_armclang\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg_armclang\test_efm32.bin .\dbg_armclang\test_efm32.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: Q_SPY Q_UTEST __FPU_PRESENT
  c include: .;..\src;..\..\..\..\include;..\..\..\..\src;..\..\..\..\ports\arm-cm\qutest;..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\3rd_party\efm32pg1b
  asm define: Stack_Size=2048 Heap_Size=16
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../../../../src/qs/: qstamp.c
    ./: test_qutest.c
  group efm32pg1b
    ../../../../3rd_party/efm32pg1b/arm/: startup_efm32pg1b.s
    ../../../../3rd_party/efm32pg1b/: system_efm32pg1b.c em_cmu.c em_emu.c em_gpio.c em_system.c em_usart.c
  group QP
    ../../../../src/qf/: qep_hsm.c qep_msm.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qf_act.c
    ../../../../src/qs/: qs.c qs_64bit.c qs_fp.c qs_rx.c qutest.c
  group QP_port
    ../../../../3rd_party/efm32pg1b/qutest/: qutest_port.c
